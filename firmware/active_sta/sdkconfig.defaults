## firmware/active_sta/sdkconfig.defaults
```kconfig
CONFIG_SHOULD_COLLECT_CSI=y
CONFIG_SEND_CSI_TO_SERIAL=y
CONFIG_ESP_WIFI_CSI_ENABLED=y
```
